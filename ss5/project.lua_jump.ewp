# IAR project project.lua_jump.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750VB ST STM32H750VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32H750xx; USE_HAL_DRIVER; NX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE; MB_ASCII_ENABLED=0; NX_DISABLE_ERROR_CHECKING; TX_DISABLE_ERROR_CHECKING
  ICCARM.CCIncludePath2: rt-thread\components\net\lwip-2.0.2\src\include\posix; rt-thread\include; rt-thread\components\net\lwip-2.0.2\src\include\netif; drivers; rt-thread\components\net\lwip-2.0.2\src\include; rt-thread\components\net\lwip-2.0.2\src\arch\include; rt-thread\libcpu\arm\cortex-m7; libraries\CMSIS\Include; rt-thread\components\net\lwip-2.0.2\src; rt-thread\components\drivers\include; drivers\include; libraries\STM32H7xx_HAL_Driver\Inc; .; applications; applications\arx; packages\fal-v0.5.0\inc; packages\FlashDB-v2.2.0\inc; rt-thread\components\net\lwip-2.0.2\src\include\ipv4; rt-thread\libcpu\arm\common; rt-thread\components\libc\compilers\common; libraries\CMSIS\Device\ST\STM32H7xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: eth_official.out
  ILINK.IlinkIcfFile: linkscripts\STM32H750VBTx\link.icf
configuration Release (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 41
  General.FPU2: 7
  OBJCOPY.OOCOutputFile: project.hex
  postbuild: powershell.exe -NoProfile -ExecutionPolicy Bypass -File "applications\modules\build_module_hex.ps1" -TargetPath "$TARGET_PATH$" -OutputDir "$TARGET_DIR$" -Ielftool "$TOOLKIT_DIR$\bin\ielftool.exe"
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/arx/: arx_example.c arx_flashdb_multi.c arx_modbus.c holding_flashdb.c w25q128_fal.c spi4_w25q128_fal.c
    applications/: elam_modbus.c main.c tag_registry.c tag_device_config.c tag_poll_scheduler.c rs485_master.c tag_config_modbus.c thread_profiler.c web_server.c
    applications/modules/: module_modbus.c module_service_api.c qspi_modules.c qspi_objects.c
    applications/modules/examples/: slot2_profiler_control.c
  group Mongoose
    libraries/mongoose/: mongoose.c
  group Board and Ethernet
    drivers/: board.c drv_clk.c drv_common.c drv_eth.c drv_gpio.c drv_usart.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
  group FlashDB and FAL
    packages/fal-v0.5.0/src/: fal.c fal_flash.c fal_partition.c
    packages/FlashDB-v2.2.0/src/: fdb.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group lwIP
    rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
  group Official STM32H7 HAL
    libraries/: startup_stm32h750xx.s
    libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c
    libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Lua 5.4 XIP
    applications/modules/lua/: lua_vm_entry.c lua_vm_module.c lua_iar_jump.s
    applications/modules/lua/src/: lapi.c lcode.c lctype.c ldebug.c ldo.c ldump.c lfunc.c lgc.c llex.c lmem.c lobject.c lopcodes.c lparser.c lstate.c lstring.c ltable.c ltm.c lundump.c lvm.c lzio.c lauxlib.c lbaselib.c ltablib.c lstrlib.c
  group Serial Device
    rt-thread/components/drivers/serial/: serial.c
